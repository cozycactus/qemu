## hw/avr32/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0-or-later
config AVR32EXP_MCU
    bool

config AVR32EXAMPLE_BOARD
    bool
    select AVR32EXP_MCU
```
